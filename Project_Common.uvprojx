# Keil uVision project Project_Common.uvprojx, settings and files
target Project (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project_Common
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Driver
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ./Src/: main.c
  group Driver
    ./Driver/: RCC.c RCC.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
